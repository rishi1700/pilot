# IAR project M433_Adc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM430 AnalogDevices ADuCM430
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\..\common; ..\..\..\common\IAR; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: M433_Adc.hex
  ILINK.IlinkOutputFile: M433_Adc.out
  ILINK.IlinkIcfFile: RTE\Device\ADuCM433\ADuCM433.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Apps
    ../../: ADuCM430_Setup.c iramCode.c main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM433/: ADuCM433.icf startup_ADuCM430.s system_ADuCM430.c
  group CMSIS-Pack/Device.Peripheral Libraries WDT
    RTE/Device/ADuCM433/: WdtLib.c WdtLib.h
  group CMSIS-Pack/Device.Peripheral Libraries UART
    RTE/Device/ADuCM433/: UrtLib.c UrtLib.h
  group CMSIS-Pack/Device.Peripheral Libraries DIO
    RTE/Device/ADuCM433/: DioLib.c DioLib.h
  group CMSIS-Pack/Device.Peripheral Libraries DAC
    RTE/Device/ADuCM433/: DacLib.c DacLib.h
  group CMSIS-Pack/Device.Peripheral Libraries CLK
    RTE/Device/ADuCM433/: ClkLib.c ClkLib.h
  group CMSIS-Pack/Device.Peripheral Libraries ADC
    RTE/Device/ADuCM433/: AdcLib.c AdcLib.h
