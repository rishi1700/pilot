<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\M433_Adc\M433_Adc.ewp</path>
    </project>
    <batchBuild />
</workspace>
