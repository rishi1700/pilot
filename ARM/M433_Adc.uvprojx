# Keil uVision project M433_Adc.uvprojx, settings and files
target Adc (6220000::V6.22::ARMCLANG)
  device: ADuCM433 Analog Devices
  pack: AnalogDevices.ADuCM430_DFP.0.6.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) IROM2(0x00080000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M430_Adc +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=3
  c include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\RTE\Device\ADuCM433\ADuCM433.sct
  group Application
    ../: main.c ADuCM430_Setup.c iramCode.c nano_globals.h nano_hw.c nano_hw.h nano_lut_50ghz.c nano_lut_50ghz.h nanoITLA.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.0.0, Device:Peripheral Libraries:ADC 0.2.0, Device:Peripheral Libraries:CLK 0.3.0, Device:Peripheral Libraries:DAC 0.5.0, Device:Peripheral Libraries:DIO 0.3.0, Device:Peripheral Libraries:GPT 0.2.0, Device:Peripheral Libraries:UART 0.2.0, Device:Peripheral Libraries:WDT 0.2.0
